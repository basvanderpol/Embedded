# Keil uVision project ex1.uvproj, settings and files
target LPC2378 (5050169::V5.05 update 2 (build 169)::.\ARMCC_505u2)
  device: LPC2378 NXP
  cpu: IRAM(0x40000000-0x40007FFF) IRAM2(0x7FE00000-0x7FE03FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: ex1 +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x40000000 size 0x8000
  memory RVCT10: RAM 0x7fe00000 size 0x4000
  group System settings
    ./: LPC2300.s
  group Program code
    ./: MCB2300 evaluationboard.c type.h main.c
    ../../../Downloads/LCD/: LCD_4bit.c
